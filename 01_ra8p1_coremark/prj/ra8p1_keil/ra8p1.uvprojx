# Keil uVision project ra8p1.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: R7KA8P1KF:CPU0 Renesas
  pack: Renesas.RA_DFP.6.4.0
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: ra8p1 +hex
  c flags: Optim=8 v6Lang=3 v6LangP=6 v6Lto=1
  c misc: @./via/rasc_armclang.via -Omax
  asm misc: --via=./via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c hal_warmstart.c
  group log
    ./log/: syscall.c
  group coremark
    ./coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
software components: Flex Software:RA Configuration 1.0.0
